# Keil uVision project LCD.uvprojx, settings and files
target LCD (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: LCD +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\FWLIB\inc;..\HARDWARE\TIMER;..\HARDWARE\MOTOR;..\HARDWARE\PWM;..\HARDWARE\RTC;..\HARDWARE\KEY;..\HARDWARE\WKUP;..\HARDWARE\BEEP;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\SRAM;..\HARDWARE\TOUCH;..\HARDWARE\SRAM;..\MALLOC;..\EMWIN\STemWin\Config;..\EMWIN\STemWin\inc;..\EMWIN\MyGui;..\HARDWARE\DS18B20
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/WKUP/: wkup.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/LCD/: ILI93xx.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
    ../HARDWARE/DS18B20/: ds18b20.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_rtc.c stm32f4xx_exti.c stm32f4xx_pwr.c
  group README
    ../: readme.txt
  group EMWIN_Config
    ../EMWIN/STemWin/Config/: GUI_X_Touch_Analog.c GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
    ../EMWIN/STemWin/OS/: GUI_X.c
  group EMWIN_LIB
    ../EMWIN/STemWin/Lib/: STemWin526_CM4_Keil.lib
  group MyGui
    ../EMWIN/MyGui/: MyGui.c
  group MALLOC
    ../MALLOC/: malloc.c
